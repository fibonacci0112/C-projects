# Keil uVision project Memory_6_7.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51CC03 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(33000000) MODP2
  output: Memory_6_7 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Memory_6_7.a51
